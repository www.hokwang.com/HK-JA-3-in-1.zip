Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-JA 3 in 1.IFC
Time: 2022-01-04T05:35:31
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: HK-JA三合一內盒(立誼法國)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-JA三合一垃圾筒(加大容量)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-JA三合一垃圾箱門
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-JA三合一擦手紙箱門
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-JA三合一烘手機外殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-JA三合一衛生組箱體
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 大扁M5×8螺絲_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 鎖頭C628S-1_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 電熱環拉釘3-12 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
